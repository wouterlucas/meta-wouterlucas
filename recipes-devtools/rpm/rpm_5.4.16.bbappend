CFLAGS_append = " -Doff64_t=_IO_off64_t"
