FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://0001-Remove-Werror-as-ccache-3.2.5-has-warning-with-GCC7-.patch"

