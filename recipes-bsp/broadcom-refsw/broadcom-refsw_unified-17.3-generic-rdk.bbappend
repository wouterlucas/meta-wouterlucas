FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-Dont-use-precompiled-headers-when-building-nexus-bas.patch"